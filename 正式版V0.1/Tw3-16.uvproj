# Keil uVision project Tw3-16.uvproj, settings and files
target Vhe-Main (ARM-ADS)
  device: M054LBN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x03FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: TW3-16 +hex
  c flags: Optim=1
  c include: .\LibM051Series;.\LibM051Series\CMSIS\CM0\CoreSupport;.\LibM051Series\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series\startup\arm;.\UserCode\inc;.\UserCode\src;.\LibM051Series\CMSIS\CM0\DeviceSupport\Nuvoton;.\LibM051Series\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series;.\LibM051Series\StdDriver\inc;.\UserCode
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Lib
    ./LibM051Series/CMSIS/CM0/CoreSupport/: core_cm0.c
    ./LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/: system_M051Series.c
    ./: startup_M051Series.s
    ./LibM051Series/StdDriver/src/: retarget.c
  group User
    ./UserCode/: main.c
    ./UserCode/src/: UserSYSCLK.c UserUart1.c UserTASK.c UserTime0.c UserADC.c UserFlash.c UserControl.c UserCelsius.c
