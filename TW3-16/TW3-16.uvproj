# Keil uVision project TW3-16.uvproj, settings and files
target TW3-16 (ARM-ADS)
  device: STM32F100C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: vhe0101stm32f100
  c flags: Optim=1
  c define: STM32F10X_MD_VL USE_STDPERIPH_DRIVER
  c include: .\USER;.\LIB\CMSIS\CM3\CoreSupport;.\LIB\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;.\LIB\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\LIB\STM32F10x_StdPeriph_Driver\inc;.\LIB\STM32F10x_StdPeriph_Driver\src;.\LIB\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group START
    ./LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md_vl.s
  group LIB
    ./LIB/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group USER_lib
    ./LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER_CODE
    ./USER/: stm32f10x_conf.h main.c stm32f10x_it.c adc.c flash.c Systick.c Control.c uart.c Task.c
    ./: dac.c
